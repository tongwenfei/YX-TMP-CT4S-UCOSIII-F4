# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa082,Pa093,Pe301
  ICCARM.CCIncludePath2: ..\..\Application; ..\..\System; ..\..\Libraries\inc; ..\..\Drivers\inc; ..\..\System\Include; ..\..\System\IAR; ..\..\UCOSIII\uC-CPU; ..\..\UCOSIII\uC-CPU\ARM-Cortex-M4\IAR; ..\..\UCOSIII\uC-LIB; ..\..\UCOSIII\uCOS_CONFIG; ..\..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\UCOSIII\uCOS-III\Source; ..\..\UCOSIII\UCOS_BSP; ..\..\Task; ..\..\GUI; ..\..\FreeModbus\modbus; ..\..\FreeModbus\modbus\ascii; ..\..\FreeModbus\modbus\functions; ..\..\FreeModbus\modbus\include; ..\..\FreeModbus\modbus\rtu; ..\..\FreeModbus\modbus\tcp; ..\..\FreeModbus\port
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: YX-TMP-CT4S.hex
  ILINK.IlinkOutputFile: YX-TMP-CT4S.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Application
    ../../Application/: global.c main.c main.h polyfit.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group Drivers/inc
    ../../Drivers/inc/: at24cxx.h delay.h font.h fontupd.h lcd.h led.h malloc.h sdio_sdcard.h spi.h sram.h sys.h text.h timer.h touch.h usart.h w25qxx.h
  group Drivers/src
    ../../Drivers/src/: adc.c ads1118.c ads1248.c delay.c ds1302.c ds18b20.c flow_PID.c fm24cl64.c key.c lcd.c ms5611.c sys.c target.c tempPID.c timer.c usart.c w25qxx.c
  group GUI
    ../../GUI/: CH_SetWindow.c ConfigWindow.c Data_Window.c MainWindow.c PassWd_SetWindow.c SampWindow.c SysInfo.c
  group Libraries/inc
    ../../Libraries/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Libraries/src
    ../../Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Modbus/modbus
    ../../FreeModbus/modbus/: mb.c
    ../../FreeModbus/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Modbus/port
    ../../FreeModbus/port/: port.c port.h portevent.c portserial.c porttimer.c
  group System
    ../../System/iar/: startup_stm32f40_41xxx.s
    ../../System/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Task
    ../../Task/: adtask.c flowcontroltask.c guitask.c keytask.c maintask.c modbustask.c rtctask.c tempcontroltask.c temppressTask.c temptask.c
  group UCOS III/UCOSIII-BSP
    ../../UCOSIII/UCOS_BSP/: bsp.c
  group UCOS III/UCOSIII_CONFIG
    ../../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOS III/UCOSIII_CORE
    ../../UCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group UCOS III/UCOSIII_CPU
    ../../UCOSIII/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group UCOS III/UCOSIII_LIB
    ../../UCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOS III/UCOSIII_PORT
    ../../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
